## drivers/media/platform/video-sniffer/Kconfig
```kconfig
config VIDEO_SNIFFER
        tristate "Video Sniffer"
        default m
        ---help---
          Driver for the Video Sniffer IP.
```
